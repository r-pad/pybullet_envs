Commit message: fixed so it's cross-plaftorm

File: models/cube.urdf (robot description, URDF)
Before this commit: robot cube.urdf, 1 links, 0 joints
Links:
- link baseLink: geometry collision box size=.05 .05 .05; visual mesh filename=panda/meshes/cube.obj scale=.05 .05 .05
